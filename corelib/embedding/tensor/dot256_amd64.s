//go:build amd64

#include "textflag.h"

// func dot256AVX2(a, b *float32) float32
TEXT ·dot256AVX2(SB), NOSPLIT, $0-20
	MOVQ a+0(FP), SI
	MOVQ b+8(FP), DI
	VXORPS Y0, Y0, Y0
	VXORPS Y1, Y1, Y1
	MOVQ $16, CX
dot256_loop:
	VMOVUPS (SI), Y2
	VMOVUPS (DI), Y3
	VFMADD231PS Y3, Y2, Y0
	VMOVUPS 32(SI), Y2
	VMOVUPS 32(DI), Y3
	VFMADD231PS Y3, Y2, Y1
	ADDQ $64, SI
	ADDQ $64, DI
	DECQ CX
	JNZ dot256_loop
	VADDPS Y0, Y1, Y0
	VEXTRACTF128 $1, Y0, X1
	VADDPS X0, X1, X0
	VHADDPS X0, X0, X0
	VHADDPS X0, X0, X0
	VZEROUPPER
	MOVSS X0, ret+16(FP)
	RET

// func dot256AVX512(a, b *float32) float32
TEXT ·dot256AVX512(SB), NOSPLIT, $0-20
	MOVQ a+0(FP), SI
	MOVQ b+8(FP), DI
	VXORPS Z0, Z0, Z0
	MOVQ $8, CX
dot256z_loop:
	VMOVUPS (SI), Z1
	VFMADD231PS (DI), Z1, Z0
	VMOVUPS 64(SI), Z1
	VFMADD231PS 64(DI), Z1, Z0
	ADDQ $128, SI
	ADDQ $128, DI
	DECQ CX
	JNZ dot256z_loop
	VEXTRACTF32X8 $1, Z0, Y1
	VADDPS Y0, Y1, Y0
	VEXTRACTF32X4 $1, Y0, X1
	VADDPS X0, X1, X0
	VHADDPS X0, X0, X0
	VHADDPS X0, X0, X0
	VZEROUPPER
	MOVSS X0, ret+16(FP)
	RET
